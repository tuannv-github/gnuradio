options:
  parameters:
    generate_options: qt_gui
    id: usrp_source
    output_language: python
    title: RX
  states: {}

blocks:
- name: Bandwidth
  id: variable_qtgui_range
  parameters:
    start: 200e3
    step: '100'
    stop: 56e6
    value: 20e6
  states: {}
- name: Frequency
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: 1e6
    stop: 6e9
    value: 100e6
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '80'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: Bandwidth
    center_freq0: Frequency
    dev_addr: '"serial=326BDB1"'
    gain0: RF_Gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
