options:
  parameters:
    generate_options: qt_gui
    id: usrp_sink
    output_language: python
    title: TX
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: var_center_frequency
  id: variable_qtgui_range
  parameters:
    start: 70e6
    step: 1e6
    stop: 6e9
    value: 100e6
  states: {}
- name: var_frequency
  id: variable_qtgui_range
  parameters:
    start: '-100e3'
    step: 1e3
    stop: 100e3
    value: '0'
  states: {}
- name: var_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '30'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: var_frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: var_center_frequency
    dev_addr: '"serial=326BDB3"'
    gain0: var_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
